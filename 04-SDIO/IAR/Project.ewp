# IAR project Project.ewp, settings and files
configuration GD32F207 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxG GD GD32F20xxG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F20X_CL
  ICCARM.CCIncludePath2: ..\..\01-Libraries\CMSIS; ..\..\01-Libraries\CMSIS\GD\GD32F20x\Include; ..\..\01-Libraries\GD32F20x_standard_peripheral\Include; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: gd32f20x_it.c LCD_disp.c LCD_disp.h main.c sdcard.c sdcard.h
  group CMSIS
    ../../01-Libraries/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Peripherals
    ../../01-Libraries/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group Startup
    ../../01-Libraries/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
