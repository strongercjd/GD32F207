# Keil uVision project Project.uvprojx, settings and files
target GD32F207 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F207VG GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\..\01-Libraries\CMSIS;..\..\01-Libraries\CMSIS\GD\GD32F20x\Include;..\..\01-Libraries\GD32F20x_standard_peripheral\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Startup
    ../../01-Libraries/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group CMSIS
    ../../01-Libraries/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Peripherals
    ../../01-Libraries/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group main
    ../: main.c gd32f20x_it.c LCD_disp.c
